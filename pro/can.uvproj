# Keil uVision project can.uvproj, settings and files
target CAN (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CAN +hex
  c flags: Optim=1
  c define: STM32F10X_HD
  c include: ..\Source\CMSIS\Core\CM3;..\Source\CMSIS\Core\CM3\startup\arm;..\Source\App;..\Source\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ../Source/App/: GLCD.c main.c stm32f10x_it.c USART.c
  group CMSIS
    ../Source/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
    ../Source/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s
  group LIB
    ../Source/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
